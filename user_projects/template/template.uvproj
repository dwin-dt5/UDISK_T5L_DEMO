# Keil uVision project template.uvproj, settings and files
target projects (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: .\obj\1.bat
  c flags: Optimize=3 SizeSpeed=1
  link misc: REMOVEUNUSED
  group template
    ./main/: main.c
    ./: STARTUP_M5.A51
