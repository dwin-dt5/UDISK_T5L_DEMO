# Keil uVision project usb_demo.uvproj, settings and files
target projects (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: .\obj\1.bat
  c flags: Optimize=3 SizeSpeed=1
  link misc: REMOVEUNUSED
  group usb_demo
    ./main/: main.c lib.h
    ./: STARTUP_M5.A51
  group lib_51
    ../../lib/: dwin_51.lib
  group lib_dgus
    ../../lib/: dwin_dgus.lib
  group lib_usb
    ../../lib/: dwin_usb.lib
  group lib_uart
    ../../lib/: dwin_uart.lib
  group lib_all
    ../../lib/: dwin.lib
