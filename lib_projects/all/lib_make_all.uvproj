# Keil uVision project lib_make_all.uvproj, settings and files
target lib_projects (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: dwin +hex (library)
  AfterMake: .\lib\dwin.bat
  c flags: Optimize=3 SizeSpeed=1
  link misc: REMOVEUNUSED
  group dwin_dgus
    ../dwin_dgus/src/: dgus.c
  group dwin_51
    ../dwin_51/src/: sys.c
  group dwin_uart
    ../dwin_uart/src/: uart.c
  group dwin_usb
    ../dwin_usb/src/: app_interface.c dgus_config.c file_sys.c para_port.c usb_dgus.c
  group user_main
    ./src/: main.c
    ./: STARTUP_M5.A51
