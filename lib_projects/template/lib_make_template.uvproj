# Keil uVision project lib_make_template.uvproj, settings and files
target lib_projects (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: template +hex (library)
  AfterMake: .\lib\dwin.bat
  c flags: Optimize=3 SizeSpeed=1
  link misc: REMOVEUNUSED
  group template
    ./src/: template.c
  group user_main
    ./src/: main.c
    ./: STARTUP_M5.A51
